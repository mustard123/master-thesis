<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>zero_mq_split_a</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>capture_freq</value></param>
<param><key>value</key><value>868.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/sili/Documents/signal_recordings/trimmed</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>address</key><value>zmq_address</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>-1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>zmq_address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>tcp://127.0.0.1:5051</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
